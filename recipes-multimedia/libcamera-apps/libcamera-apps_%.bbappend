FILES:${PN} += "/usr/lib/rpicam_app.so.*"

